Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-11-30T15:31:15
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort
FlowDirection: SINK
Pset_DistributionPortPipe - PortNumber: 1; ConnectionType: WELDED
MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 15 mm; ConnectorDiameter: 15 mm; NominalWidth: 15 mm; NominalHeight: 15 mm

# IfcEnergyConversionDevice: Winston Exposed Bath & Shower Mono (2 ways tap) (Cross Handle), AmericanStandard_BathAndShowerMixer_Exposed_Winston_(FFAST703-6T1500BT0):Winston Exposed Bath & Shower Mono (2 ways tap) (Cross Handle):3546
In: Level 1
Pset_ManufacturerTypeInformation - ModelReference: Winston Exposed Bath & Shower Mono (2 ways tap) (Cross Handle); Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: Winston Exposed Bath & Shower Mono (2 ways tap) (Cross Handle)
Constraints - Elevation: 0 mm
Dimensions - Area: 0.0199601 m2; Volume: 0.000165167 m3
Identity Data - Mark: 1
Mechanical - System Classification: Undefined
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Plumbing Fixtures; Family: AmericanStandard_BathAndShowerMixer_Exposed_Winston_(FFAST703-6T1500BT0): Winston Exposed Bath & Shower Mono (2 ways tap) (Cross Handle); Family and Type: AmericanStandard_BathAndShowerMixer_Exposed_Winston_(FFAST703-6T1500BT0): Winston Exposed Bath & Shower Mono (2 ways tap) (Cross Handle); InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: AmericanStandard_BathAndShowerMixer_Exposed_Winston_(FFAST703-6T1500BT0): Winston Exposed Bath & Shower Mono (2 ways tap) (Cross Handle); Type Id: AmericanStandard_BathAndShowerMixer_Exposed_Winston_(FFAST703-6T1500BT0): Winston Exposed Bath & Shower Mono (2 ways tap) (Cross Handle); WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Data(Type) - ConnectionSize: n/a; FlowRate: n/a; InstallationType: n/a; ProductCategory: n/a; ProductGroup: n/a; ProductWeight: n/a; StyleSegment: n/a; SubCategory: n/a
Identity Data(Type) - Assembly Code: D2010700; Description: Winston Exposed Bath & Shower Mono (2 ways tap) (Cross Handle); Keynote: N13; Manufacturer: American Standard; Model: Winston Exposed Bath & Shower Mono (2 ways tap) (Cross Handle); OmniClass Number: 23.45.05.14.17; OmniClass Title: Showers; Type Comments: FFAST703-6T1500BT0; Type Name: Winston Exposed Bath & Shower Mono (2 ways tap) (Cross Handle); URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: bimstore; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/ffast703-6t1500bt0/document/object-user-guide; BIMObjectName: AmericanStandard_BathAndShowerMixer_Exposed_Winston_(FFAST703-6T1500BT0); NBSDescription: Shower mixers; NBSNote: n/a; NBSObjectName: American Standard - Shower mixers; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/335
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_87_81; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-12-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/ffast703-6t1500bt0/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/ffast703-6t1500bt0/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/ffast703-6t1500bt0/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/ffast703-6t1500bt0/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/ffast703-6t1500bt0/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: AmericanStandard_BathAndShowerMixer_Exposed_Winston_(FFAST703-6T1500BT0); Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: Chrome; ModelNumber: FFAST703-6T1500BT0; ModelReference: Winston Exposed Bath & Shower Mono (2 ways tap) (Cross Handle); ProductionYear: 2021; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: Winston Exposed Bath & Shower Mono (2 ways tap) (Cross Handle); WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
